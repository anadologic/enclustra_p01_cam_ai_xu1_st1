# system-conf.dtsi is generated by PetaLinux; in Yocto it comes from this layer.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://system-conf.dtsi"

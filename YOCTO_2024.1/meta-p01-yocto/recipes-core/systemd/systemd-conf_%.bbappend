# Static IP 192.168.2.10/24 on the Ethernet ports (same file as PetaLinux configs/systemd-conf).
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
